# Keil uVision project project.uvprojx, settings and files
target Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: D:\MDK5\ARM\ARMCC\bin\fromelf.exe --bin -o  ./Flash/Obj/@L.bin  ./Flash/Obj/@L.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\bsp;..\..\User\bsp\inc;..\..\User;..\..\Libraries\CMSIS\Include;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM3;..\..\MQTT;..\..\Ethernet;..\..\Ethernet\W5500;..\..\Internet\DHCP;..\..\Internet\DNS;..\..\User\app\src;..\..\User\app\inc;..\..\Internet\NTP;..\..\Internet\HTTP
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../../User/: main.c includes.h FreeRTOSConfig.h cJSON.c mqtt.c transport.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f10x_it.c stm32f10x_assert.c bsp_sht3x.c bsp_sht3x_iic.c
    ../../User/bsp/src/: bsp_led.c bsp_uart_fifo.c timer.c bsp_iwdg.c bsp_cpu_flash.c bsp_mqtt_ota.c bsp_fsmc_sram.c bsp_key.c bsp_dma.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_can.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_fsmc.c stm32f10x_dma.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group FreeRTOS/Source
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../../FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ../../FreeRTOS/portable/MemMang/: heap_4.c
  group Doc
    ../../Doc/: 工程说明.txt 顺势为设备软件版本说明.txt
  group MQTT
    ../../MQTT/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group Ethernet
    ../../Ethernet/: socket.c spi.c wizchip_conf.c utility.c
    ../../Ethernet/W5500/: w5500.c
  group Internet
    ../../Internet/DHCP/: dhcp.c
    ../../Internet/DNS/: dns.c
    ../../Internet/NTP/: ntp.c
  group Http
    ../../Internet/HTTP/: http_server.c httputil.c
  group APP
    ../../User/app/src/: app_plat.c app_flash.c app_nrf52832.c app_system.c app_device_alarm.c
software components: CMSIS:CORE 5.0.1
